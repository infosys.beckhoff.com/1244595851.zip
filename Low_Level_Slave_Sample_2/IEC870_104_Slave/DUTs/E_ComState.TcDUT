TYPE E_ComState :
(
	INIT := 0,
	IDLE,
	CONNECT,
	DATATRANSFER,
	DISCONNECT
);
END_TYPE
